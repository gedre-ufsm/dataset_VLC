options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: complex_random_led
    output_language: python
    title: complex_random_led
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '76'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1e6
    step: 100e3
    stop: 50e6
    value: 10e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '32768'
    min: '-32768'
    num_samps: '500000'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/workstation/Documentos/Rodrigo/GNU_UTEC/complex_random_led (GUI)/enviado.mat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/workstation/Documentos/Rodrigo/GNU_UTEC/complex_random_led (GUI)/recebido.mat
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /mnt/06A720A57C1A5BEA/Documents and Settings/mrbea/Meu Drive/Doutorado/UTEC/GNU Radio/Vitalio/QPSK/source.mat
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '128'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Embedded Python Block example - encuentra el máximo en un vector de longitud 512"""

          def __init__(self, vectorSize=1024):  # no se necesitan parámetros adicionales
              """Inicializa el bloque"""
              gr.sync_block.__init__(
                  self,
                  name='Encuentra el Máximo',  # Aparecerá en GRC
                  in_sig=[(np.float32,vectorSize)],  # Tipo de datos de entrada: float
                  out_sig=[(np.float32,1)]  #Salida será el índice del máximo valor en el vector
              )
              
              self.prev_delay = 25
              self.delay = 25
              self.portName = 'dlyOutput'
              self.message_port_register_out(pmt.intern(self.portName))
              
        
          def work(self, input_items, output_items):
              """Encuentra el índice del máximo en el vector de entrada"""
              # Usamos np.argmax para encontrar el índice del máximo valor en el vector
              for vectorIndex in range(len(input_items[0])):
              	max_index = np.argmax(input_items[0][vectorIndex])
              	# Colocamos el índice del máximo en la salida
              	output_items[0][vectorIndex] = max_index
              
              self.delay = max_index
              if (self.delay != self.prev_delay):
                      PMT_msg = pmt.from_long(self.delay)
                      self.message_port_pub(pmt.intern(self.portName), PMT_msg)
                      self.prev_delay = self.delay	
              	
              		
              return len(output_items[0])
    alias: vector_size=vector_size
    vectorSize: vector_size
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vector_size)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"enviado"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Maximo"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"RECEIVED"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"SENT"'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: vector_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tuning
    dev_addr: '"addr0=192.168.136.139"'
    gain0: rf_gain
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tuning
    dev_addr: '"addr0=192.168.136.136"'
    dev_args: '""'
    gain0: rf_gain
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [analog_random_source_x_1, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
